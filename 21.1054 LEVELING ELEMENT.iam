# Autodesk Inventor assembly: 21.1054 LEVELING ELEMENT
## iProperties
Created: 2007-04
Part Number: 21.1054 LEVELING ELEMENT
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
